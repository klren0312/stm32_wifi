# Keil uVision project stm32f103.uvproj, settings and files
target onenet-edp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\user;.\NET\protocol\inc;.\NET\device\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c
  group hardware
    ./hardware/src/: adxl345.c at24c02.c beep.c delay.c hwtimer.c i2c.c info.c key.c led.c oled.c selfcheck.c sht20.c usart.c adc.c tcrt5000.c lcd1602.c duoji.c rthongwai.c fengshan.c light.c jiaredian.c
  group user
    ./user/: main.c
  group net_protocol
    ./NET/protocol/src/: fault.c onenet.c
  group net_device
    ./NET/device/src/: net_io.c net_device.c
